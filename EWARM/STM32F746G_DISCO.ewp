# IAR project STM32F746G_DISCO.ewp, settings and files
configuration STM32F746G_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_BPP=24
  ICCARM.CCIncludePath2: ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F746G_DISCO.hex
  ILINK.IlinkOutputFile: STM32F746G_DISCO.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: stm32f746xx_flash.icf
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
  group Drivers/BSP
    ../Drivers/BSP/: stm32746g_discovery_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/Components
    ../Drivers/Components/ft5336/: ft5336.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/include/: FreeRTOS.h
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Regular_20_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/pooltemp_screen/: PoolTempViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group TouchGFX/gui/main_screen
    ../TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/pooltemp_screen
    ../TouchGFX/gui/src/pooltemp_screen/: PoolTempPresenter.cpp PoolTempView.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core.a
